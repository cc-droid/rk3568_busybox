## kernel/drivers/char/helloworld/Kconfig
```kconfig
config HELLOWORLD
    bool "hello world"
    default y
    help 
        "hello world"
```
